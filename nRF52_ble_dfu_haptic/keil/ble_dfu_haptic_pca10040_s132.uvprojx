# Keil uVision project ble_dfu_haptic_pca10040_s132.uvprojx, settings and files
target nrf52832_xxaa (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BLE_STACK_SUPPORT_REQD S132 NRF_SD_BLE_API_VERSION=3 BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET SOFTDEVICE_PRESENT NRF52832 NRF_DFU_SETTINGS_VERSION=1 NRF52 SWI_DISABLE0
  c include: .\config;..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\ble\ble_advertising;..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\ble\common;..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\ble\peer_manager;..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\ble\ble_services\ble_dfu;..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\drivers_nrf\clock;..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\drivers_nrf\common;..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\drivers_nrf\delay;..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\drivers_nrf\gpiote;..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\drivers_nrf\hal;..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\drivers_nrf\spi_master;..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\drivers_nrf\uart;..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\libraries\bootloader;..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\libraries\bootloader\ble_dfu;..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\libraries\bootloader\dfu;..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\libraries\button;..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\libraries\crc32;..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\libraries\experimental_section_vars;..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\libraries\fds;..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\libraries\fstorage;..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\libraries\log;..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\libraries\log\src;..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\libraries\sensorsim;..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\libraries\timer;..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\libraries\util;..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\softdevice\common\softdevice_handler;..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\softdevice\s132\headers;..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\softdevice\s132\headers\nrf52;..\..\..\nRF5_SDK_12.1.0_0d23e2a\examples\bsp;..\..\..\nRF5_SDK_12.1.0_0d23e2a\external\segger_rtt
  asm define: BLE_STACK_SUPPORT_REQD S132 NRF_SD_BLE_API_VERSION=3 BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET SOFTDEVICE_PRESENT NRF52832 NRF52 SWI_DISABLE0
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-DS132,-DNRF_SD_BLE_API_VERSION=3,-DBOARD_PCA10040,-DNRF52_PAN_12,-DNRF52_PAN_15,-DNRF52_PAN_20,-DNRF52_PAN_30,-DNRF52_PAN_31,-DNRF52_PAN_36,-DNRF52_PAN_51,-DNRF52_PAN_53,-DNRF52_PAN_54,-DNRF52_PAN_55,-DNRF52_PAN_58,-DNRF52_PAN_62,-DNRF52_PAN_63,-DNRF52_PAN_64,-DCONFIG_GPIO_AS_PINRESET,-DSOFTDEVICE_PRESENT,-DNRF52832,-DNRF52,-DSWI_DISABLE0
  asm include: ..\..\..\config\ble_app_template_pca10040_s132;..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\components\ble\ble_dtm;..\..\..\..\..\..\components\ble\ble_racp;..\..\..\..\..\..\components\ble\ble_services\ble_ancs_c;..\..\..\..\..\..\components\ble\ble_services\ble_ans_c;..\..\..\..\..\..\components\ble\ble_services\ble_bas;..\..\..\..\..\..\components\ble\ble_services\ble_bas_c;..\..\..\..\..\..\components\ble\ble_services\ble_cscs;..\..\..\..\..\..\components\ble\ble_services\ble_cts_c;..\..\..\..\..\..\components\ble\ble_services\ble_dfu;..\..\..\..\..\..\components\ble\ble_services\ble_dis;..\..\..\..\..\..\components\ble\ble_services\ble_gls;..\..\..\..\..\..\components\ble\ble_services\ble_hids;..\..\..\..\..\..\components\ble\ble_services\ble_hrs;..\..\..\..\..\..\components\ble\ble_services\ble_hrs_c;..\..\..\..\..\..\components\ble\ble_services\ble_hts;..\..\..\..\..\..\components\ble\ble_services\ble_ias;..\..\..\..\..\..\components\ble\ble_services\ble_ias_c;..\..\..\..\..\..\components\ble\ble_services\ble_lbs;..\..\..\..\..\..\components\ble\ble_services\ble_lbs_c;..\..\..\..\..\..\components\ble\ble_services\ble_lls;..\..\..\..\..\..\components\ble\ble_services\ble_nus;..\..\..\..\..\..\components\ble\ble_services\ble_nus_c;..\..\..\..\..\..\components\ble\ble_services\ble_rscs;..\..\..\..\..\..\components\ble\ble_services\ble_rscs_c;..\..\..\..\..\..\components\ble\ble_services\ble_tps;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\ble\nrf_ble_qwr;..\..\..\..\..\..\components\ble\peer_manager;..\..\..\..\..\..\components\drivers_nrf\adc;..\..\..\..\..\..\components\drivers_nrf\clock;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\comp;..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\i2s;..\..\..\..\..\..\components\drivers_nrf\lpcomp;..\..\..\..\..\..\components\drivers_nrf\pdm;..\..\..\..\..\..\components\drivers_nrf\ppi;..\..\..\..\..\..\components\drivers_nrf\pwm;..\..\..\..\..\..\components\drivers_nrf\qdec;..\..\..\..\..\..\components\drivers_nrf\rng;..\..\..\..\..\..\components\drivers_nrf\rtc;..\..\..\..\..\..\components\drivers_nrf\saadc;..\..\..\..\..\..\components\drivers_nrf\spi_master;..\..\..\..\..\..\components\drivers_nrf\spi_slave;..\..\..\..\..\..\components\drivers_nrf\swi;..\..\..\..\..\..\components\drivers_nrf\timer;..\..\..\..\..\..\components\drivers_nrf\twi_master;..\..\..\..\..\..\components\drivers_nrf\twis_slave;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\drivers_nrf\wdt;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\..\components\libraries\crc32;..\..\..\..\..\..\components\libraries\csense;..\..\..\..\..\..\components\libraries\csense_drv;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\fds;..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\components\libraries\hardfault;..\..\..\..\..\..\components\libraries\hci;..\..\..\..\..\..\components\libraries\led_softblink;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\low_power_pwm;..\..\..\..\..\..\components\libraries\mailbox;..\..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\..\components\libraries\pwm;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\sensorsim;..\..\..\..\..\..\components\libraries\slip;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\twi;..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\bsp;..\..\..\..\..\..\external\segger_rtt;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0x61000
  memory RVCT9: RAM 0x20002138 size 0xdec8
  group Application
    ../: main.c ble_haptic.c spi_haptic.c
    ./config/: sdk_config.h
  group Board Support
    ../../../nRF5_SDK_12.1.0_0d23e2a/examples/bsp/: bsp.c bsp_btn_ble.c
  group Documentation
    ../: license.txt
  group nRF_BLE
    ../../../nRF5_SDK_12.1.0_0d23e2a/components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../../nRF5_SDK_12.1.0_0d23e2a/components/ble/ble_advertising/: ble_advertising.c
    ../../../nRF5_SDK_12.1.0_0d23e2a/components/ble/peer_manager/: gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c pm_buffer.c pm_mutex.c security_dispatcher.c security_manager.c
    ../../../nRF5_SDK_12.1.0_0d23e2a/components/ble/ble_services/ble_dfu/: ble_dfu.c
  group nRF_DFU
    ../../../nRF5_SDK_12.1.0_0d23e2a/components/libraries/bootloader/dfu/: nrf_dfu_settings.c nrf_dfu_flash.c nrf_dfu_mbr.c nrf_dfu_transport.c nrf_dfu_utils.c
  group nRF_Drivers
    ../../../nRF5_SDK_12.1.0_0d23e2a/components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../nRF5_SDK_12.1.0_0d23e2a/components/drivers_nrf/common/: nrf_drv_common.c
    ../../../nRF5_SDK_12.1.0_0d23e2a/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../nRF5_SDK_12.1.0_0d23e2a/components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../nRF5_SDK_12.1.0_0d23e2a/components/drivers_nrf/hal/: nrf_nvmc.c
    ../../../nRF5_SDK_12.1.0_0d23e2a/components/drivers_nrf/spi_master/: nrf_drv_spi.c
  group nRF_Libraries
    ../../../nRF5_SDK_12.1.0_0d23e2a/components/libraries/button/: app_button.c
    ../../../nRF5_SDK_12.1.0_0d23e2a/components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_mapped_flags.c
    ../../../nRF5_SDK_12.1.0_0d23e2a/components/libraries/fifo/: app_fifo.c
    ../../../nRF5_SDK_12.1.0_0d23e2a/components/libraries/timer/: app_timer.c
    ../../../nRF5_SDK_12.1.0_0d23e2a/components/libraries/crc16/: crc16.c
    ../../../nRF5_SDK_12.1.0_0d23e2a/components/libraries/fds/: fds.c
    ../../../nRF5_SDK_12.1.0_0d23e2a/components/libraries/fstorage/: fstorage.c
    ../../../nRF5_SDK_12.1.0_0d23e2a/components/libraries/hardfault/: hardfault_implementation.c
    ../../../nRF5_SDK_12.1.0_0d23e2a/components/libraries/sensorsim/: sensorsim.c
    ../../../nRF5_SDK_12.1.0_0d23e2a/components/libraries/crc32/: crc32.c
  group nRF_Log
    ../../../nRF5_SDK_12.1.0_0d23e2a/components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_Segger_RTT
    ../../../nRF5_SDK_12.1.0_0d23e2a/external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../../../nRF5_SDK_12.1.0_0d23e2a/components/softdevice/common/softdevice_handler/: softdevice_handler.c
target flash_s132_nrf52_3.0.0_softdevice (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: as above
  output: s132_nrf52_3.0.0_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c include: ..\..\..\config\ble_app_template_pca10040_s132;..\..\..\config;..\config
  asm misc: --cpreproc_opts=
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0x61000
  memory RVCT9: RAM 0x20002128 size 0xded8
software components: CMSIS:CORE 4.3.0, Device:Startup 8.9.0
