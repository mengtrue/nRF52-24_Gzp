# Keil uVision project gzll_dynamic_pairig_host_pca10040.uvprojx, settings and files
target nrf52832_xxaa (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: USE_SD_HW_RESOURCES NRF52832 NRF52 NRF52_PAN_58 NRF52_PAN_64 BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_54 CONFIG_GPIO_AS_PINRESET NRF52_PAN_55 GAZELL_PRESENT GAZELL_ALTERNATIVE_RESOURCES SWI_DISABLE0
  c include: ..\config;..\..\..\config;..\..\..\..\..\nRF5_SDK_13.0.0-1.alpha_055eef3\components\boards;..\..\..\..\..\nRF5_SDK_13.0.0-1.alpha_055eef3\components\drivers_nrf\common;..\..\..\..\..\nRF5_SDK_13.0.0-1.alpha_055eef3\components\drivers_nrf\delay;..\..\..\..\..\nRF5_SDK_13.0.0-1.alpha_055eef3\components\drivers_nrf\gpiote;..\..\..\..\..\nRF5_SDK_13.0.0-1.alpha_055eef3\components\drivers_nrf\hal;..\..\..\..\..\nRF5_SDK_13.0.0-1.alpha_055eef3\components\drivers_nrf\uart;..\..\..\..\..\nRF5_SDK_13.0.0-1.alpha_055eef3\components\libraries\bsp;..\..\..\..\..\nRF5_SDK_13.0.0-1.alpha_055eef3\components\libraries\button;..\..\..\..\..\nRF5_SDK_13.0.0-1.alpha_055eef3\components\libraries\log;..\..\..\..\..\nRF5_SDK_13.0.0-1.alpha_055eef3\components\libraries\log\src;..\..\..\..\..\nRF5_SDK_13.0.0-1.alpha_055eef3\components\libraries\timer;..\..\..\..\..\nRF5_SDK_13.0.0-1.alpha_055eef3\components\libraries\util;..\..\..\..\..\nRF5_SDK_13.0.0-1.alpha_055eef3\components\proprietary_rf\gzll;..\..\..\..\..\nRF5_SDK_13.0.0-1.alpha_055eef3\components\softdevice\s132\headers
  asm define: as above
  asm misc: --cpreproc_opts=-DUSE_SD_HW_RESOURCES,-DNRF52832,-DNRF52,-DNRF52_PAN_58,-DNRF52_PAN_64,-DBOARD_PCA10040,-DNRF52_PAN_12,-DNRF52_PAN_15,-DNRF52_PAN_20,-DNRF52_PAN_31,-DNRF52_PAN_36,-DNRF52_PAN_51,-DNRF52_PAN_54,-DCONFIG_GPIO_AS_PINRESET,-DNRF52_PAN_55,-DGAZELL_PRESENT,-DGAZELL_ALTERNATIVE_RESOURCES,-DSWI_DISABLE0
  asm include: ..\..\..\config;..\..\..\..\..\..\..\..\..\components;..\..\..\..\..\..\..\..\..\components\boards;..\..\..\..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\..\..\..\components\proprietary_rf\gzll;..\..\..\..\..\..\..\..\..\components\toolchain;..\..\..;..\..\..\..\..\..\..\..\..\external\segger_rtt;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../../nRF5_SDK_13.0.0-1.alpha_055eef3/components/boards/: boards.c
  group Board Support
    ../../../../../nRF5_SDK_13.0.0-1.alpha_055eef3/components/libraries/bsp/: bsp.c bsp_nfc.c
  group Documentation
    ../../../: license.txt
  group nRF_Drivers
    ../../../../../nRF5_SDK_13.0.0-1.alpha_055eef3/components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../nRF5_SDK_13.0.0-1.alpha_055eef3/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../nRF5_SDK_13.0.0-1.alpha_055eef3/components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../../nRF5_SDK_13.0.0-1.alpha_055eef3/components/drivers_nrf/hal/: nrf_ecb.c nrf_nvmc.c
  group nRF_Libraries
    ../../../../../nRF5_SDK_13.0.0-1.alpha_055eef3/components/libraries/button/: app_button.c
    ../../../../../nRF5_SDK_13.0.0-1.alpha_055eef3/components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_errors.c
    ../../../../../nRF5_SDK_13.0.0-1.alpha_055eef3/components/libraries/timer/: app_timer.c
  group nRF_Log
    ../../../../../nRF5_SDK_13.0.0-1.alpha_055eef3/components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_Properitary_RF
    ../../../../../nRF5_SDK_13.0.0-1.alpha_055eef3/components/proprietary_rf/gzll/arm/: gzll_nrf52_sd_resources_arm.lib
    ../../../../../nRF5_SDK_13.0.0-1.alpha_055eef3/components/proprietary_rf/gzll/: nrf_gzp.c nrf_gzp_host.c nrf_gzp_host_nrf5x.c
  group nRF_Segger_RTT
    ../../../../../nRF5_SDK_13.0.0-1.alpha_055eef3/external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.11.1
