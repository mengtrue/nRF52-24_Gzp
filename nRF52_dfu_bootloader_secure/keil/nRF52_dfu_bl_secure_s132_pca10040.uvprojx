# Keil uVision project nRF52_dfu_bl_secure_s132_pca10040.uvprojx, settings and files
target nrf52832_xxaa_s132 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa_s132 +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: NRF_DFU_DEBUG_VERSION BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 SVC_INTERFACE_CALL_AS_NORMAL_FUNCTION S132 NRF_SD_BLE_API_VERSION=3 BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET SWI_DISABLE0 SOFTDEVICE_PRESENT NRF52832 NRF52 NRF_DFU_SETTINGS_VERSION=1
  c include: .\config;..\..\nRF52_dfu_bootloader_secure;..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\ble\common;..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\drivers_nrf\common;..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\drivers_nrf\delay;..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\drivers_nrf\hal;..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\drivers_nrf\rng;..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\drivers_nrf\uart;..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\libraries\bootloader;..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\libraries\bootloader\ble_dfu;..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\libraries\bootloader\dfu;..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\libraries\crc32;..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\libraries\crypto;..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\libraries\ecc;..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\libraries\experimental_section_vars;..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\libraries\fstorage;..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\libraries\log;..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\libraries\log\src;..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\libraries\scheduler;..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\libraries\sha256;..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\libraries\svc;..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\libraries\timer;..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\libraries\util;..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\softdevice\common\softdevice_handler;..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\softdevice\s132\headers;..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\softdevice\s132\headers\nrf52;..\..\..\nRF5_SDK_12.1.0_0d23e2a\examples\bsp;..\..\..\nRF5_SDK_12.1.0_0d23e2a\external\micro-ecc\micro-ecc;..\..\..\nRF5_SDK_12.1.0_0d23e2a\external\nano-pb;..\..\..\nRF5_SDK_12.1.0_0d23e2a\external\segger_rtt
  asm define: as above
  asm misc: --cpreproc_opts=-DNRF_DFU_DEBUG_VERSION,-DBLE_STACK_SUPPORT_REQD,-D__HEAP_SIZE=0,-DSVC_INTERFACE_CALL_AS_NORMAL_FUNCTION,-DS132,-DNRF_SD_BLE_API_VERSION=3,-DBOARD_PCA10040,-DNRF52_PAN_12,-DNRF52_PAN_15,-DNRF52_PAN_20,-DNRF52_PAN_30,-DNRF52_PAN_31,-DNRF52_PAN_36,-DNRF52_PAN_51,-DNRF52_PAN_53,-DNRF52_PAN_54,-DNRF52_PAN_55,-DNRF52_PAN_58,-DNRF52_PAN_62,-DNRF52_PAN_63,-DNRF52_PAN_64,-DCONFIG_GPIO_AS_PINRESET,-DSWI_DISABLE0,-DSOFTDEVICE_PRESENT,-DNRF52832,-DNRF52,-DNRF_DFU_SETTINGS_VERSION=1
  asm include: ..\..\config\secure_dfu_secure_dfu_ble_s132_pca10040_debug;..\..\config;..\..\..\..\..\components;..\..\..\..\..\components\ble\common;..\..\..\..\..\components\drivers_nrf\clock;..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\components\drivers_nrf\rng;..\..\..\..\..\components\libraries\bootloader;..\..\..\..\..\components\libraries\bootloader\ble_dfu;..\..\..\..\..\components\libraries\bootloader\ble_dfu\includes;..\..\..\..\..\components\libraries\bootloader\dfu;..\..\..\..\..\components\libraries\crc32;..\..\..\..\..\components\libraries\crypto;..\..\..\..\..\components\libraries\ecc;..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\components\libraries\hci;..\..\..\..\..\components\libraries\log;..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\components\libraries\sha256;..\..\..\..\..\components\libraries\svc;..\..\..\..\..\components\libraries\timer;..\..\..\..\..\components\libraries\util;..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\..\..\components\toolchain;..\..\..\..\bsp;..\..;..\..\..\..\..\external\micro-ecc\micro-ecc;..\..\..\..\..\external\nano-pb;..\..\..\..\..\external\segger_rtt;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x73000 size 0xb000
  memory RVCT9: RAM 0x20002c00 size 0xd380
  group Application
    ../: main.c dfu_public_key.c dfu_req_handling.c dfu-cc.pb.c
    ./config/: sdk_config.h
  group Documentation
    ../: license.txt readme.txt
  group nRF_BLE
    ../../../nRF5_SDK_12.1.0_0d23e2a/components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
  group nRF_BLE_DFU
    ../../../nRF5_SDK_12.1.0_0d23e2a/components/libraries/bootloader/ble_dfu/: nrf_ble_dfu.c
  group nRF_Bootloader
    ../../../nRF5_SDK_12.1.0_0d23e2a/components/libraries/bootloader/dfu/: nrf_dfu_utils.c nrf_dfu_settings.c nrf_dfu_mbr.c nrf_dfu_transport.c nrf_dfu.c nrf_dfu_flash.c
    ../../../nRF5_SDK_12.1.0_0d23e2a/components/libraries/bootloader/: nrf_bootloader.c nrf_bootloader_app_start.c nrf_bootloader_info.c
  group nRF_Drivers
    ../../../nRF5_SDK_12.1.0_0d23e2a/components/drivers_nrf/hal/: nrf_nvmc.c
    ../../../nRF5_SDK_12.1.0_0d23e2a/components/drivers_nrf/rng/: nrf_drv_rng.c
    ../../../nRF5_SDK_12.1.0_0d23e2a/components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../nRF5_SDK_12.1.0_0d23e2a/components/drivers_nrf/common/: nrf_drv_common.c
  group nRF_Libraries
    ../../../nRF5_SDK_12.1.0_0d23e2a/components/libraries/sha256/: sha256.c
    ../../../nRF5_SDK_12.1.0_0d23e2a/components/libraries/hci/: hci_mem_pool.c
    ../../../nRF5_SDK_12.1.0_0d23e2a/components/libraries/fstorage/: fstorage.c
    ../../../nRF5_SDK_12.1.0_0d23e2a/components/libraries/util/: nrf_assert.c app_util_platform.c
    ../../../nRF5_SDK_12.1.0_0d23e2a/components/libraries/crc32/: crc32.c
    ../../../nRF5_SDK_12.1.0_0d23e2a/components/libraries/timer/: app_timer.c app_timer_appsh.c
    ../../../nRF5_SDK_12.1.0_0d23e2a/components/libraries/crypto/: nrf_crypto.c
    ../../../nRF5_SDK_12.1.0_0d23e2a/components/libraries/ecc/: ecc.c
    ../../../nRF5_SDK_12.1.0_0d23e2a/components/libraries/scheduler/: app_scheduler.c
  group nRF_Log
    ../../../nRF5_SDK_12.1.0_0d23e2a/components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_Segger_RTT
    ../../../nRF5_SDK_12.1.0_0d23e2a/external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../../../nRF5_SDK_12.1.0_0d23e2a/components/softdevice/common/softdevice_handler/: softdevice_handler.c softdevice_handler_appsh.c
  group nRF_micro_ecc
    ../../../nRF5_SDK_12.1.0_0d23e2a/external/micro-ecc/nrf52_keil/armgcc/: micro_ecc_lib_nrf52.lib
  group nano-pb
    ../../../nRF5_SDK_12.1.0_0d23e2a/external/nano-pb/: pb_common.c pb_decode.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.9.0
