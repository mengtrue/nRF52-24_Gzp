# Keil uVision project esb_ptx_pca10040.uvprojx, settings and files
target nrf52832_xxaa (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: NRF52832 BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET BSP_DEFINES_ONLY ESB_PRESENT NRF52
  c include: ..\config;..\..\..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\drivers_nrf\common;..\..\..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\drivers_nrf\delay;..\..\..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\drivers_nrf\hal;..\..\..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\drivers_nrf\spi_slave;..\..\..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\drivers_nrf\uart;..\..\..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\libraries\log;..\..\..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\libraries\log\src;..\..\..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\libraries\util;..\..\..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\proprietary_rf\esb;..\..\..\..\..\nRF5_SDK_12.1.0_0d23e2a\components\softdevice\s132\headers;..\..\..\..\..\nRF5_SDK_12.1.0_0d23e2a\examples\bsp;..\..\..\..\..\nRF5_SDK_12.1.0_0d23e2a\external\segger_rtt
  asm define: as above
  asm misc: --cpreproc_opts=-DNRF52832,-DBOARD_PCA10040,-DNRF52_PAN_12,-DNRF52_PAN_15,-DNRF52_PAN_20,-DNRF52_PAN_30,-DNRF52_PAN_31,-DNRF52_PAN_36,-DNRF52_PAN_51,-DNRF52_PAN_53,-DNRF52_PAN_54,-DNRF52_PAN_55,-DNRF52_PAN_58,-DNRF52_PAN_62,-DNRF52_PAN_63,-DNRF52_PAN_64,-DCONFIG_GPIO_AS_PINRESET,-DBSP_DEFINES_ONLY,-DESB_PRESENT,-DNRF52
  asm include: ..\..\..\config\esb_ptx_pca10040;..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\proprietary_rf\esb;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\bsp;..\..\..;..\..\..\..\..\..\external\segger_rtt;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group Documentation
    ../../../: license.txt
  group nRF_Drivers
    ../../../../../nRF5_SDK_12.1.0_0d23e2a/components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../../nRF5_SDK_12.1.0_0d23e2a/components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../nRF5_SDK_12.1.0_0d23e2a/components/drivers_nrf/spi_slave/: nrf_drv_spis.c
  group nRF_Libraries
    ../../../../../nRF5_SDK_12.1.0_0d23e2a/components/libraries/util/: app_error.c app_error_weak.c nrf_assert.c app_util_platform.c
  group nRF_Log
    ../../../../../nRF5_SDK_12.1.0_0d23e2a/components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_Properitary_RF
    ../../../../../nRF5_SDK_12.1.0_0d23e2a/components/proprietary_rf/esb/: nrf_esb.c
  group nRF_Segger_RTT
    ../../../../../nRF5_SDK_12.1.0_0d23e2a/external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.9.0
