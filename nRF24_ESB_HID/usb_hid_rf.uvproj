# Keil uVision project usb_hid_rf.uvproj, settings and files
target USB_HID_RF (MCS-51)
  device: nRFLU1P-F32 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF) XRAM (0x8000-0x87FF) CLOCK(16000000) MODC2
  output: usb_hid_rf +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\nRFgo SDK 2.3.0.10040\source_code\compiler\common;..\..\nRFgo SDK 2.3.0.10040\source_code\hal;..\..\nRFgo SDK 2.3.0.10040\source_code\hal\nrf24l01p;..\..\nRFgo SDK 2.3.0.10040\source_code\hal\nrf24lu1p
  link misc: REMOVEUNUSED
  group SRC
    ./: STARTUP.A51 main.c
  group USB
    ./: usb_desc.c
  group HAL
    ../../nRFgo SDK 2.3.0.10040/source_code/hal/nrf24lu1p/: hal_flash.c hal_usb.c hal_usb_hid.c hal_nrf_hw.c hal_spi.c
    ../../nRFgo SDK 2.3.0.10040/source_code/hal/nrf24l01p/: hal_nrf.c
    ../../nRFgo SDK 2.3.0.10040/source_code/hal/: hal_delay.c
