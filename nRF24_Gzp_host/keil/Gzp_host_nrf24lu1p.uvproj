# Keil uVision project Gzp_host_nrf24lu1p.uvproj, settings and files
target gazell host (MCS-51)
  device: nRFLU1P-F16 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM (0x8000-0x87FF) CLOCK(16000000) MODC2
  output: nrf24lu1p_gzp_host +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: EX_PROJ_LU1
  c include: ..\..\..\nRFgo SDK 2.3.0.10040\source_code\compiler\common;..\..\..\nRFgo SDK 2.3.0.10040\source_code\gazell\common;..\..\..\nRFgo SDK 2.3.0.10040\source_code\gazell\nrf24lu1;..\..\..\nRFgo SDK 2.3.0.10040\source_code\params;..\..\..\nRFgo SDK 2.3.0.10040\source_code\hal;..\..\..\nRFgo SDK 2.3.0.10040\source_code\hal\nrf24l01p;..\..\..\nRFgo SDK 2.3.0.10040\source_code\hal\nrf24lu1p;..\..\..\nRFgo SDK 2.3.0.10040\source_code\lib\assertions
  link misc: REMOVEUNUSED
  group app
    ../: main.c
  group gzll
    ../../../nRFgo SDK 2.3.0.10040/source_code/gazell/common/: gzll.c gzp_host.c gzp.c
    ../../../nRFgo SDK 2.3.0.10040/source_code/gazell/nrf24lu1/: gzll_timer_isr.c gzll_mcu.c gzll_radio_isr.c gzp_host_lu1.c
  group hal
    ../../../nRFgo SDK 2.3.0.10040/source_code/hal/nrf24lu1p/: hal_nrf_hw.c hal_flash.c hal_aes.c
    ../../../nRFgo SDK 2.3.0.10040/source_code/hal/nrf24l01p/: hal_nrf.c
    ../../../nRFgo SDK 2.3.0.10040/source_code/hal/: hal_delay.c
