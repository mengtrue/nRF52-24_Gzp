# Keil uVision project gzll_host_w_dynamic_pairing_nrf24lu1p.uvproj, settings and files
target gazell host (MCS-51)
  device: nRFLU1P-F16 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM (0x8000-0x87FF) CLOCK(16000000) MODC2
  output: gzll_host_w_dyn_pair_nrf24lu1p +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: EX_PROJ_LU1
  c include: ..\..\..\nRFgo SDK 2.3.0.10040\source_code\hal;..\..\..\nRFgo SDK 2.3.0.10040\source_code\hal\nrf24l01p;..\..\..\nRFgo SDK 2.3.0.10040\source_code\gazell\common;..\..\..\nRFgo SDK 2.3.0.10040\source_code\gazell\nrf24lu1;..\..\..\nRFgo SDK 2.3.0.10040\source_code\params;..\..\..\nRFgo SDK 2.3.0.10040\source_code\lib\assertions;..\..\..\nRFgo SDK 2.3.0.10040\source_code\hal\nrf24lu1p;..\..\..\nRFgo SDK 2.3.0.10040\source_code\compiler\c51;..\..\..\nRFgo SDK 2.3.0.10040\source_code\compiler\common;..\..\nRF24_Gzp_host
  link misc: REMOVEUNUSED
  group app
    ../: main.c STARTUP.A51
  group gzll
    ../../../nRFgo SDK 2.3.0.10040/source_code/gazell/common/: gzll.c gzp.c gzp_host.c
    ../../../nRFgo SDK 2.3.0.10040/source_code/gazell/nrf24lu1/: gzll_timer_isr.c gzll_mcu.c gzll_radio_isr.c gzp_host_lu1.c
  group hal
    ../../../nRFgo SDK 2.3.0.10040/source_code/hal/nrf24lu1p/: hal_nrf_hw.c hal_flash.c hal_aes.c hal_usb.c hal_usb_hid.c
    ../../../nRFgo SDK 2.3.0.10040/source_code/hal/nrf24l01p/: hal_nrf.c
    ../../../nRFgo SDK 2.3.0.10040/source_code/hal/: hal_delay.c
  group usb
    ../: usb_desc.c
