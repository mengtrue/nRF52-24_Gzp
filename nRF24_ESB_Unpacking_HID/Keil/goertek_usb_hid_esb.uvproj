# Keil uVision project goertek_usb_hid_esb.uvproj, settings and files
target Goertek_glove_dongle (MCS-51)
  device: nRFLU1P-F32 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF) XRAM (0x8000-0x87FF) CLOCK(16000000) MODC2
  output: goertek_glove_dongle +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\nRF24_ESB_Unpacking_HID;..\..\..\nRFgo SDK 2.3.0.10040\source_code\compiler\common;..\..\..\nRFgo SDK 2.3.0.10040\source_code\hal;..\..\..\nRFgo SDK 2.3.0.10040\source_code\hal\nrf24l01p;..\..\..\nRFgo SDK 2.3.0.10040\source_code\hal\nrf24lu1p
  link misc: REMOVEUNUSED
  group App
    ../: main.c STARTUP.A51
  group USB
    ../: usb_desc.c
  group HAL
    ../../../nRFgo SDK 2.3.0.10040/source_code/hal/nrf24l01p/: hal_nrf.c
    ../../../nRFgo SDK 2.3.0.10040/source_code/hal/nrf24lu1p/: hal_nrf_hw.c hal_usb.c hal_usb_hid.c hal_spi.c
    ../../../nRFgo SDK 2.3.0.10040/source_code/hal/: hal_delay.c
